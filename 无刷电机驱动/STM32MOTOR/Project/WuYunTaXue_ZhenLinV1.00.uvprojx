# Keil uVision project WuYunTaXue_ZhenLinV1.00.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Bldc_ZhenLinV1.00
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Include
    ../Include/: Bldc.h Define.h Main.h Initialize.h Device.h DisPlay.h Protect.h
  group Source
    ../Source/: Bldc.c Main.c Startup.s Initialize.c DisPlay.c Protect.c
